 AREA SEARCH,CODE,READOONLY
 ENTRY;
START
 MOV R2,#0;
 MOV R3,#0;
 MOV R7,#2;
 LDR R6=DATA1;
LOOP
 MOV R1,#32;
 LDRR0,[R6],#4;
LOOP1
 MOV R0,R0,R0,#1;
 BHI ONE;
ZERO
 ADD R3,R3,#1;
 BSKIP;
ONE
 ADD R2,R2,#1;
 BNE LOOP1;
 SUBS R7,R7,#1;
 CMP R7 ,#0;
 BNE LOOP;
 SAME BSAME
 DATA1 DCP 0X00000007,0X00000001
 END;